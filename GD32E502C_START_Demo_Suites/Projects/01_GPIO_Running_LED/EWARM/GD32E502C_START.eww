<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32E502C_START.ewp</path>
    </project>
    <batchBuild />
</workspace>
