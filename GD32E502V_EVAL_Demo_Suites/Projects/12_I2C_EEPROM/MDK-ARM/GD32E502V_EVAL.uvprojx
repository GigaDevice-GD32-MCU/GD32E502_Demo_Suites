# Keil uVision project GD32E502V_EVAL.uvprojx, settings and files
target GD32E502V_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32E502VD GigaDevice
  pack: GigaDevice.GD32E502_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E502
  c include: ..\;..\..\..\..\GD32E502_Firmware_Library\CMSIS;..\..\..\..\GD32E502_Firmware_Library\CMSIS\GD\GD32E502\Include;..\..\..\..\GD32E502_Firmware_Library\GD32E502_standard_peripheral\Include;..\..\..\Utilities;..\Soft_Drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: gd32e502_it.c main.c systick.c
  group CMSIS
    ../../../../GD32E502_Firmware_Library/CMSIS/GD/GD32E502/Source/: system_gd32e502.c
  group GD32E502_Peripherals
    ../../../../GD32E502_Firmware_Library/GD32E502_standard_peripheral/Source/: gd32e502_adc.c gd32e502_bkp.c gd32e502_can.c gd32e502_cmp.c gd32e502_crc.c gd32e502_dac.c gd32e502_dbg.c gd32e502_dma.c gd32e502_exti.c gd32e502_fmc.c gd32e502_fwdgt.c gd32e502_gpio.c gd32e502_i2c.c gd32e502_mfcom.c gd32e502_misc.c gd32e502_pmu.c gd32e502_rcu.c gd32e502_rtc.c gd32e502_spi.c gd32e502_syscfg.c gd32e502_timer.c gd32e502_trigsel.c gd32e502_usart.c gd32e502_wwdgt.c
  group GD32E502V_EVAL
    ../../../Utilities/: gd32e502v_eval.c
  group Soft_Drive
    ../Soft_Drive/: at24cxx.c i2c.c
  group Startup
    ../../../../GD32E502_Firmware_Library/CMSIS/GD/GD32E502/Source/ARM/: startup_gd32e502.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
