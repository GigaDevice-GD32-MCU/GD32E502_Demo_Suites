# IAR project GD32E502V_EVAL.ewp, settings and files
configuration GD32E502 (ARM, debug)
  General.OGChipSelectEditMenu: GD32E502xD GD GD32E502xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32E502
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32E502_Firmware_Library\CMSIS; ..\..\..\..\GD32E502_Firmware_Library\CMSIS\GD\GD32E502\Include; ..\..\..\..\GD32E502_Firmware_Library\GD32E502_standard_peripheral\Include; ..\..\..\Utilities; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    ../: gd32e502_it.c main.c
    ../Soft_Drive/: rtc.c
  group CMSIS
    ../../../../GD32E502_Firmware_Library/CMSIS/GD/GD32E502/Source/: system_gd32e502.c
  group Doc
    ../: readme.txt
  group GD32E502_EVAL
    ../../../Utilities/: gd32e502v_eval.c
  group GD32E502_Peripherals
    ../../../../GD32E502_Firmware_Library/GD32E502_standard_peripheral/Source/: gd32e502_adc.c gd32e502_bkp.c gd32e502_can.c gd32e502_cmp.c gd32e502_crc.c gd32e502_dac.c gd32e502_dbg.c gd32e502_dma.c gd32e502_exti.c gd32e502_fmc.c gd32e502_fwdgt.c gd32e502_gpio.c gd32e502_i2c.c gd32e502_mfcom.c gd32e502_misc.c gd32e502_pmu.c gd32e502_rcu.c gd32e502_rtc.c gd32e502_spi.c gd32e502_syscfg.c gd32e502_timer.c gd32e502_trigsel.c gd32e502_usart.c gd32e502_wwdgt.c
  group Startup
    ../../../../GD32E502_Firmware_Library/CMSIS/GD/GD32E502/Source/IAR/: startup_gd32e502.s
